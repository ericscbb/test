# Keil uVision project s3xxx.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: s3xxx +hex
  c flags: Optim=1
  c include: .\Source\User\Main;.\Source\CMSIS\Core\CM3;.\Source\STM32F10x_StdPeriph_Driver\inc;.\Source\User\LCD_Driver;.\Source\User\RTC;.\Source\User\I2C;.\Source\User\SD_Driver;.\Source\User\FATS;.\Source\User\24LC02;.\Source\User\RMI
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ./Source/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ./Source/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
  group Main
    ./Source/User/Main/: main.c usart.c stm32f10x_it.c stm32f10x_conf.h usually.h
    ./Source/STM32F10x_StdPeriph_Driver/src/: stm32f10x_exti.c stm32f10x_tim.c stm32f10x_rtc.c
  group LCD_Driver
    ./Source/User/LCD_Driver/: LCD_Drive.c hz16.c LCD_Drive.h bmp2.c font.h
  group SDIO
    ./Source/User/SD_Driver/: sdcard.c
  group FATS
    ./Source/User/FATS/: ff.c diskio.c ccsbcs.c
  group StdPeriph_Driver
    ./Source/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_bkp.c stm32f10x_pwr.c
  group I2C
    ./Source/User/I2C/: iic.c
  group RMI
    ./Source/User/RMI/: pdt_scan.c rmi_func11.c rmi_func54.c rmi_func1A.c rmi_func34.c
  group 24LC02
    ./Source/User/24LC02/: 24LC02.c
  group RTC
    ./Source/User/RTC/: rtc.c
  group Readme
    ./Source/User/Doc/: Readme.c
